/**********************************************************************************************************************
 *  FILE DESCRIPTION
 *  -----------------------------------------------------------------------------------------------------------------*/
/**        \file  SYSTICK.c
 *        \brief  
 *
 *      \details  
 *
 *
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  INCLUDES
 *********************************************************************************************************************/
#include "SYSTICK.h"
#include "STD_TYPES.h"

/**********************************************************************************************************************
*  LOCAL MACROS CONSTANT\FUNCTION
*********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL DATA 
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL DATA
 *********************************************************************************************************************/
volatile  u32 SYSTEM_MS=0; 
cb_type CallBackPtr=0;

/**********************************************************************************************************************
 *  LOCAL FUNCTION PROTOTYPES
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL FUNCTIONS
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL FUNCTIONS
 *********************************************************************************************************************/


/******************************************************************************
* \Syntax          : Std_ReturnType FunctionName(AnyType parameterName)        
* \Description     : Describe this service                                    
*                                                                             
* \Sync\Async      : Synchronous                                               
* \Reentrancy      : Non Reentrant                                             
* \Parameters (in) : parameterName   Parameter Describtion                     
* \Parameters (out): None                                                      
* \Return value:   : Std_ReturnType  E_OK
*                                    E_NOT_OK                                  
*******************************************************************************/
void SYS_INIT(u32 clock){
		
    SYSTICK->STCTRL =0x0;
	SYSTICK->STRELOAD =clock-1;                    
	SYSTICK->STCURRENT=0x0;
	SYSTICK->STCTRL =0x07;
	
}

void INCREMENT(void) {
	SYSTEM_MS++;
}

u32 millis(void){
	return SYSTEM_MS;
}
void system_msdelay(u32 delay_ms){
	
	u32 start = millis() ;
	while((millis()-start)< delay_ms);

}

void Register_cb(cb_type ptr){

if(0!=ptr){
	CallBackPtr = ptr;
}

}

void SysTick_Handler(void){
if(0!= CallBackPtr){
CallBackPtr();
	}
}

/**********************************************************************************************************************
 *  END OF FILE: FileName.c
 *********************************************************************************************************************/








